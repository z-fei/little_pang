# Keil uVision project mrobot.uvprojx, settings and files
target mrobot (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mrobot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: _TEST, _DMA_USART, _ENABLE_MPU6050
  c include: .\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./src/: main.c
  group Driver
    ./src/driver/: battery.c beep.c boarddrv.c crc.c led.c motor.c softdelay.c usart.c watchdog.c exti.c protocol.c encoder.c
  group MPU6050
    ./src/driver/mpu6050/: mpu6050.c mpuiic.c
    ./src/driver/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group utils
    ./src/utils/: filters.c hwconf.c stm32f10x_it.c
software components: Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
